# IAR project sha256_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; ENABLE_ASSERT; CC2538_USE_ALTERNATE_INTERRUPT_MAP
  ICCARM.CCIncludePath2: ../../../../inc; ../../../../source; ../../../utils
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sha256_example.bin
  ILINK.IlinkOutputFile: sha256_example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../source/: sha256_example.c
    ../../../startup_files/: startup_iar.c
    ../../../utils/: uartstdio.c
  group driverlib
    ../../../../source/: adc.c aes.c ccm.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c pka.c sha256.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
