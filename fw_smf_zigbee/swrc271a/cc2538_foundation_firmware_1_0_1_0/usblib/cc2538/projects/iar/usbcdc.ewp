# IAR project usbcdc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -f "usblib_iar.cfg"
  ICCARM.CCIncludePath2: ..\..\source\library; ..\..\source\library\cc2538; ..\..\..\..\driverlib\cc2538\inc; ..\..\..\..\driverlib\cc2538\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  ILINK.IlinkOutputFile: usbcdc.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f "usbcdc_iar.cfg"
  group (top)
    ./: usbcdc_iar.cfg
  group source/cdc
    ../../source/class_cdc/: app_usb_descriptor.c app_usb_descriptor.h usb_cdc.c usb_cdc.h usb_cdc_hooks.c
  group source/library
    ../../source/library/: hw_usb_aliases.h usb_descriptor_defs.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_in_buffer.c usb_in_buffer.h usb_interrupt.h usb_out_buffer.c usb_out_buffer.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group source/library/cc2538
    ../../source/library/cc2538/: usb.c usb.h usb_firmware_library_headers.h usb_interrupt.c usb_suspend.c
