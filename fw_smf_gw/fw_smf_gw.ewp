# IAR project fw_smf_gw.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM; USE_RTOS=1; PRINTF_FLOAT_ENABLE; PRINTF_ADVANCED_ENABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: Source; Source/Board; Source/Sensor; Source/Task; Source/Flash; Source/Flash/Device; Source/Interface; Source/Ethernet; Source/Ethernet/MQTT_API; Source/Ethernet/Lwip_2.0.0; Source/Ethernet/Lwip_2.0.0/port; Source/Ethernet/Lwip_2.0.0/port/arch; Source/Ethernet/Lwip_2.0.0/src; Source/Ethernet/Lwip_2.0.0/src/include; Source/Ethernet/Lwip_2.0.0/src/include/lwip; Library/CMSIS/Include; Library/devices; Library/devices/MK64F12/drivers; Library/devices/MK64F12/utilities; Library/rtos/freertos_8.2.3/Source; Library/devices/MK64F12; Library/rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; Library/rtos/freertos_8.2.3/Source/include; Source/SDCard; Source/SDCard/sdmmc; Source/SDCard/sdmmc/src; Source/SDCard/sdmmc/inc; Source/SDCard/sdmmc/port; Source/SDCard/fatfs; Source/SDCard/fatfs/option
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: Source
  OBJCOPY.OOCOutputFile: fw_smf_gw.hex
  ILINK.IlinkOutputFile: fw_smf_gw.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    Source/: AppData.h CheckMsg.c CheckMsg.h FreeRTOSConfig.h IOControl.c IOControl.h main.c main.h Parse.c Parse.h ProcessMsg.c ProcessMsg.h
  group Application/Board
    Source/Board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group Application/Ethernet
    Source/Ethernet/: MQTTClient.c MQTTClient.h
  group Application/Ethernet/Lwip_2.0.0
    Source/Ethernet/Lwip_2.0.0/: fsl_phy.c fsl_phy.h
  group Application/Ethernet/Lwip_2.0.0/port
    Source/Ethernet/Lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group Application/Ethernet/Lwip_2.0.0/port/arch
    Source/Ethernet/Lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group Application/Ethernet/Lwip_2.0.0/src/api
    Source/Ethernet/Lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Application/Ethernet/Lwip_2.0.0/src/core
    Source/Ethernet/Lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Application/Ethernet/Lwip_2.0.0/src/core/ipv4
    Source/Ethernet/Lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Application/Ethernet/Lwip_2.0.0/src/core/ipv6
    Source/Ethernet/Lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Application/Ethernet/Lwip_2.0.0/src/include/lwip
    Source/Ethernet/Lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group Application/Ethernet/Lwip_2.0.0/src/include/lwip/priv
    Source/Ethernet/Lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group Application/Ethernet/Lwip_2.0.0/src/include/lwip/prot
    Source/Ethernet/Lwip_2.0.0/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Application/Ethernet/Lwip_2.0.0/src/include/netif
    Source/Lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group Application/Ethernet/Lwip_2.0.0/src/include/netif/ppp
    Source/Ethernet/Lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group Application/Ethernet/Lwip_2.0.0/src/include/netif/ppp/polarssl
    Source/Ethernet/Lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group Application/Ethernet/Lwip_2.0.0/src/include/posix
    Source/Ethernet/Lwip_2.0.0/src/include/posix/: errno.h netdb.h
  group Application/Ethernet/Lwip_2.0.0/src/include/posix/sys
    Source/Ethernet/Lwip_2.0.0/src/include/posix/sys/: socket.h
  group Application/Ethernet/Lwip_2.0.0/src/netif
    Source/Ethernet/Lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group Application/Ethernet/Lwip_2.0.0/src/netif/ppp
    Source/Ethernet/Lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group Application/Ethernet/MQTTLib
    Source/Ethernet/MQTT_API/: mqtt.c mqtt.h mqtt_opts.h
  group Application/Interface
    Source/Interface/: RTC.c RTC.h UART.c UART.h
  group Application/SDCard
    Source/SDCard/: ffconf.h FileAccess.c FileAccess.h UserFile.c UserFile.h
  group Application/SDCard/fatfs
    Source/SDCard/fatfs/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c fsl_sd_disk.c fsl_sd_disk.h integer.h
  group Application/SDCard/sdmmc/inc
    Source/SDCard/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group Application/SDCard/sdmmc/port
    Source/SDCard/sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group Application/SDCard/sdmmc/src
    Source/SDCard/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group Application/Task
    Source/Task/: EthTask.c EthTask.h ProcessTask.c ProcessTask.h SDCardTask.c SDCardTask.h WhoAmITask.c WhoAmITask.h
  group doc
    Source/: readme.txt
  group drivers
    Library/devices/MK64F12/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_enet.c fsl_enet.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group drivers/freertos
    Library/devices/MK64F12/drivers/: fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_uart_freertos.c fsl_uart_freertos.h
  group freertos
    Library/rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    Library/rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    Library/rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    Library/rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group startup
    Library/devices/MK64F12/iar/: startup_MK64F12.s
    Library/devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group utilities
    Library/devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
